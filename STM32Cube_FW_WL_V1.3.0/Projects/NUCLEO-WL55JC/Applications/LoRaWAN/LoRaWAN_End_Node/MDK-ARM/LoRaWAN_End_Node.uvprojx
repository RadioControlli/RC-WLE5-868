# Keil uVision project LoRaWAN_End_Node.uvprojx, settings and files
target LoRaWAN_End_Node (6130001::V6.13.1::.\ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x20008000-0x2000BFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: LoRaWAN_End_Node +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WL55xx,BJJA_XO
  c include: ../Core/Inc;../LoRaWAN/App;../LoRaWAN/Target;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Drivers/STM32WLxx_HAL_Driver/Inc;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Utilities/trace/adv_trace;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Utilities/misc;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Utilities/sequencer;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Utilities/timer;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Utilities/lpm/tiny_lpm;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/LmHandler/Packages;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Drivers/CMSIS/Device/ST/STM32WLxx/Include;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/Crypto;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/Mac/Region;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/Mac;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/LmHandler;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/Utilities;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/SubGHz_Phy;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WLxx_Nucleo
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20008000 size 0x4000
  scatter file: stm32wl55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c flash_if.c stm32_lpm_if.c sys_app.c sys_debug.c sys_sensors.c timer_if.c adc_if.c usart_if.c rtc.c subghz.c usart.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Application/User/LoRaWAN/Target
    ../LoRaWAN/Target/: radio_board_if.c
  group Application/User/LoRaWAN/App
    ../LoRaWAN/App/: app_lorawan.c CayenneLpp.c lora_app.c lora_info.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/STM32WLxx_HAL_Driver
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Middlewares/LoRaWAN
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/LmHandler/Packages/: LmhpCompliance.c LmhpPackagesRegistration.c
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/Crypto/: cmac.c lorawan_aes.c soft-se.c
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/Mac/Region/: Region.c RegionAS923.c RegionAU915.c RegionBaseUS.c RegionCN470.c RegionCN470A20.c RegionCN470A26.c RegionCN470B20.c RegionCN470B26.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/LmHandler/: LmHandler.c NvmDataMgmt.c
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/LoRaWAN/Utilities/: utilities.c
  group Middlewares/SubGHz_Phy
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio.c radio_driver.c radio_fw.c
  group Utilities
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Utilities/trace/adv_trace/: stm32_adv_trace.c
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Utilities/sequencer/: stm32_seq.c
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Utilities/timer/: stm32_timer.c
    C:/Users/Weli/STM32Cube/Repository/STM32Cube_FW_WL_V1.3.0/Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
